Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2026-03-29T14:58:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Mar 29 14:58:45 2026 * Host: DESKTOP-EKL9I0B * Database: C:\Users\WINDOW~1\AppData\Local\Temp\e875e42d-5a28-41c5-b756-9761396ec8b1\ebc53f2d-4ee2-4eab-85ad-02ffe0d8efa4\ifc * Database version: 5507 * Database creation date: Sun Mar 29 14:58:39 2026 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Mar 29 14:58:39 2026 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Mar 29 14:58:39 2026 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_348355 | SINK
Port_348355 | SOURCE

# IfcFlowTerminal: CLU033I0-1CAAULW00:CLU033I0-1CAAULW00, CLU033I0-1CAAULW00:CLU033I0-1CAAULW00:348355
In: Level 1
Type - Material: American Standard - Vitreous China - White, American Standard - Brass
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: CLU033I0-1CAAULW00
Material: American Standard - Brass, American Standard - Vitreous China - White
Pset_DistributionFlowElementCommon - Reference: CLU033I0-1CAAULW00; sets with these values: 2
